Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-15T14:50:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 15 14:50:43 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{3873666B-BE09-439A-AAED-919EA008FE17}\ifc * Database version: 5507 * Database creation date: Thu Mar 15 14:50:28 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 15 14:50:29 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 15 14:50:29 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: 0010670_1230ES, 0010670_1230ES:0010670_1230ES:380609
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Plastic_Dark Grey, JLG_Plastic_Yellow, JLG_Paint_White, JLG_Paint_Black, JLG_Paint_Orange, JLG_Steel, JLG_Paint_Beige, JLG_Rubber_Light Grey, JLG_Metal Paint_Black, JLG_Plastic_Red, JLG_Metal Paint_White
Type - Data - Batteries: 4 x 6v 220 Ah; Break over angle: 25% (14°); Drive: 24V Electric, 8hp (6kW); Drive Speed Elevator: 0.8kph (0.5mph); Drive Speed lowered: 4.8kph (3mph); Gradeability: 25% (14°); Gross Vehicle Weight (ANSI): 805 kg (1775 lbs); Gross Vehicle Weight (CE): 789 kg (1740 lbs); Ground Clearence: 0.066m (0 ft 2.6 in); Hydraulic Tank Capasity: 3 L (0.79 gal); Lift down Time: 15 sec; Lift up time: 12 sec; Max Ground Bearing Pressure (ANSI): 8.65 kg/cm2 (123 psi); Max Ground Bearing Pressure (CE): 8.65 kg/cm2 (123 psi); Platform Capacity (ANSI): 227 kg (500 lbs); Platform Capacity (CE): 230 kg (507 lbs); Platform Height: 3.66 m (12 ft 0 in); Platform Size: 1.01 m x 0.686 m ( 3 ft 4 in x 2 ft 3 in); Turning Radius Inside: 0.112 m (0 ft 4.4 in); Turning Radius Outside: 1.462 m (4 ft 9.5 in); Tyres: 100 X 323 Non Marking; Working Height (ANSI): 5.48 m (18 ft 0 in); Working Height (CE): 5.66 m (18 ft 7 in)
Type - Dimensions - H: 774.25 mm; H1: 1548.5 mm; H2: 2322.75 mm; H3: 3097 mm; Hp: 3660 mm; Platform_Height: 4000 mm; Platform Height Maximum: Max Height 3.66m (12 ft 0 in); Transportation Condition: no
Type - General - Mast Boom Lifts: JLG_1230ES; Platform Side Entry: 1.01 m x 0.686 m ( 3 ft 4 in x 2 ft 3 in)
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: 0010670_1230ES; URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 0010670_1230ES; NBSDescription: Mast Boom Lifts; NBSNote: n/a; NBSObjectName: JLG_1230ES_Mast Boom Lifts; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 0010670_1230ES; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 1230ES; ModelReference: JLG - Mast Boom Lifts; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Mast Boom Lifts; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 43.7929 m2; Turning Radius: no; Volume: 0.181001 m3; Working Area: no
Identity Data - Mark: 12
Other - Family: 0010670_1230ES: 0010670_1230ES; Family and Type: 0010670_1230ES: 0010670_1230ES; Type: 0010670_1230ES: 0010670_1230ES; Type Id: 0010670_1230ES: 0010670_1230ES; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: Phase 1
